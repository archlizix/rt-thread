# Keil uVision project template.uvprojx, settings and files
target rt-thread_gd32f10x (ARM-ADS)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-gd32f10x
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.4.0
